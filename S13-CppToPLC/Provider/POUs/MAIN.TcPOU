PROGRAM MAIN
VAR
	m : UDINT;
	
	fbCalc : FB_Calculation('MAIN.fbCalc');
	//use this via onlinechange for BSOD x : ARRAY[0..100] OF LREAL; 
END_VAR

m := m + 1;

END_PROGRAM
